# Keil uVision project OLED_v1.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OLED_v1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group UserApp
    ./: oled_v1main.cpp
  group LibApp
    ./: fonts.c ssd1306.c ssd1306_i2c.c fonts.h ssd1306.h ssd1306_i2c.h Tipkalo.h Tipkalo.cpp
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0
